# Keil uVision project bootloader.uvprojx, settings and files
target boot (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: bootloader.bin +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F40XX USE_STDPERIPH_DRIVER
  c include: .\user_include;.\user&port_manage;.\src;.\Libraries\STM32F4xx_StdPeriph_Driver;.\Libraries\CMSIS\Include;.\Libraries\Device\STM32F4xx\Include;.\Libraries\STM32F4xx_StdPeriph_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1fc00
  memory RVCT10: RAM 0x2001fc00 size 0x400
  group Source
    ./src/: bootloader.c gpio.c main.c stm32f4xx_it.c system_stm32f4xx.c uart.c startup_stm32f40_41xxx.s
  group Driver
    ./Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_crc.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c
    ./user&port_manage/: Sys_init_port.c
